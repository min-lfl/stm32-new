# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\start;.\User;.\Linrary;.\System;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h system_stm32f10x.c stm32f10x.h system_stm32f10x.h
  group Library
    ./Linrary/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h MyDMA.c MyDMA.h Usart.c Usart.h I2C_Software.c I2C_Software.h I2C_Hardware.c I2C_Hardware.h SPI_Software.c SPI_Software.h SPI_Hardware.c SPI_Hardware.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h Buzzer.c Buzzer.h LightSensor.c LightSensor.h OLED.c OLED.h OLED_Font.h CountSensor.c CountSensor.h Encoder.c Encoder.h PWM.c PWM.h motor.c motor.h IC.c IC.h Encoder_time.c Encoder_time.h AD.c AD.h MPU6050_Sensor.c MPU6050_Sensor.h MPU6050_Hardware.c MPU6050_Hardware.h MPU6050_reg.h W25Q64_Sensor.c W25Q64_Sensor.h W25Q64_Hardware.c W25Q64_Hardware.h
